# Keil uVision project UART.uvprojx, settings and files
target LedBlink (6190000::V6.19::ARMCLANG)
  device: STM32F411VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LedBlink
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F4XX,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000
  c include: ..\LedBlink;..\..\STM32F4-master\STM32F4 Standard Peripheral Library\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\STM32F4-master\STM32F4 Standard Peripheral Library\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\STM32F4-master\STM32F4 Standard Peripheral Library\Libraries\CMSIS\Include;..\..\tm_stm32f4_all
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c defines.h
    ../../STM32F4-master/STM32F4 Standard Peripheral Library/Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_tim.c
  group STM32F4_Discovery
    ./: delay.c delay.h stm32f4_discovery.h stm32f4_discovery.c
  group STM32F4_StdPeriph_Driver
    ../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_syscfg.c stm32f4xx_exti.c stm32f4xx_sdio.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_dma.c stm32f4xx_usart.c
    ../../STM32F4-master/STM32F4 Standard Peripheral Library/Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_adc.c
  group CIMSIS
    ../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group TM_Lib
    ../../tm_stm32f4_all/: tm_stm32f4_gpio.c tm_stm32f4_usart.c
